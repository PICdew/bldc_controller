# IAR project bldc_controller.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F031C6 ST STM32F031C6
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: STM32F031x6
  ICCARM.CCIncludePath2: ..\src\lib\CMSIS\Device\ST\STM32F0xx\Include; ..\src\system\inc; ..\src\lib\CMSIS\Include; ..\src\config; ..\src\lib\qpn\include; ..\src\lib\qpn\ports\arm-cm\qv\iar; ..\src\board\inc; ..\src\configs; ..\src\application\blinky\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: bldc_controller.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group application/blinky
    ../src/application/blinky/src/: blinky.c
  group board
    ../src/board/src/: board.c
  group device
    ../src/board/src/: system_stm32f0xx.c
  group qpn
    ../src/lib/qpn/src/qfn/: qepn.c qfn.c
    ../src/lib/qpn/src/qvn/: qvn.c
    ../src/lib/qpn/ports/arm-cm/qv/iar/: qvn_port.c
  group startup
    ../src/lib/CMSIS/Device/ST/STM32F0xx/Source/iar/: startup_stm32f031x6.s
  group system
    ../src/system/src/: main.c
